FILESEXTRAPATHS_prepend := "${THISDIR}/linux:"
SRC_URI += "file://rtl8152.cfg"
